# Keil uVision project testTFTLCD.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: testTFTLCD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\CORE;..\FWLIB\inc;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\COLOR_SENSOR_TCS34725;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\TFTLCD;..\HARDWARE\DISTANCE_SENSOR_VL6180X;..\HARDWARE\FPGA_SIGNALS;..\HARDWARE\DISTANCE_SENSOR_HC-SR04
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c system_stm32f4xx.c stm32f4xx_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TFTLCD/: tftlcd.c
    ../HARDWARE/COLOR_SENSOR_TCS34725/: TCS34725_iic.c
    ../HARDWARE/DISTANCE_SENSOR_VL6180X/: VL6180X_iic.c
    ../HARDWARE/FPGA_SIGNALS/: FPGA_signals.c
    ../HARDWARE/DISTANCE_SENSOR_HC-SR04/: HC_SR04.c HC_SR04.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
